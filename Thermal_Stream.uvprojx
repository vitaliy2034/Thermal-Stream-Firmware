# Keil uVision project Thermal_Stream.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Thermal_Stream
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=4
  c include: .\Inc;.\Inc\Dev_Drv;.\Inc\Dev_lib
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Inc
    ./Inc/: device_common.h device_config.h main.h
  group Src
    ./Src/: main.c
  group Inc_Drv
    ./Inc/Dev_Drv/: drv_bt.h drv_temp.h
  group Src_Drv
    ./Src/Dev_drv/: drv_bt.c drv_temp.c
  group Src_SP
    ./Src/: sp_bt_task.c
  group Inc_SP
    ./Inc/: sp_bt_task.h
  group Inc_Lib
    ./Inc/Dev_lib/: lib_log.h
  group Src_Lib
    ./Src/Dev_lib/: lib_log.c
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
